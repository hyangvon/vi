Commit message: 1

File: urdf/7_pendulum.urdf (robot description, URDF)
Before this commit: robot planar_3r_pendulum, 9 links, 8 joints
Links:
- added link link_tcp; visual sphere radius=0.03
Joints:
- added joint joint_tcp: type fixed, parent link7, child link_tcp, origin xyz=0 0 -1.0 rpy=0 0 0
